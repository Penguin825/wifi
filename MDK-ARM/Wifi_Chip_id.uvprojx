# Keil uVision project Wifi_Chip_id.uvprojx, settings and files
target Wifi_Scan_ex (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Wifi_Chip_id Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,CONF_WINC_USE_SPI,NM_EDGE_INTERRUPT,CONF_WINC_DEBUG
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\config;..\bsp\include;..\bus_wrapper\include;..\common\include;..\driver\include;..\driver\source;..\socket\include;..\socket\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group bsp
    ../bsp/source/: nm_bsp_samd21.c
  group bus_wrapper
    ../bus_wrapper/source/: nm_bus_wrapper_samd21.c
  group common
    ../common/source/: nm_common.c
  group driver
    ../driver/source/: m2m_hif.c m2m_ota.c m2m_periph.c m2m_wifi.c nmasic.c nmbus.c nmdrv.c nmi2c.c nmspi.c nmuart.c
  group socket
    ../socket/source/: socket.c
  group config
    ../config/: conf_board - Copy.h conf_board.h conf_clocks.h conf_extint.h conf_spi.h conf_winc.h
